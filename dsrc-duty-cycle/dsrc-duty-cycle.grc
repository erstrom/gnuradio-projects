<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>avg_len</value></param>
<param><key>value</key><value>int(samp_rate/100000)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>burst_count_function_probe</value></param>
<param><key>block_id</key><value>power_power_stats_0</value></param>
<param><key>function_name</key><value>delta_burst_count</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>channel_freq + center_freq_offset</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_offset</value></param>
<param><key>value</key><value>5.7E6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_freq</value></param>
<param><key>value</key><value>5900E6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>duty_cycle_function_probe</value></param>
<param><key>block_id</key><value>power_power_stats_0</value></param>
<param><key>function_name</key><value>delta_avg_duty_cycle</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20E6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>time_sink_nbr_of_points</value></param>
<param><key>value</key><value>int(time_sink_time_base * samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>time_sink_time_base</value></param>
<param><key>value</key><value>5E-3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0</value></param>
<param><key>value</key><value>burst_count_function_probe</value></param>
<param><key>label</key><value>Delta burst count</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0_0</value></param>
<param><key>value</key><value>duty_cycle_function_probe</value></param>
<param><key>label</key><value>Duty cycle</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq_offset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/gnuradio/dev/al-test-recording3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>5E6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000E3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>power_moving_rms</key>
<param><key>id</key><value>power_moving_rms_0</value></param>
<param><key>history_len</key><value>avg_len</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>power_power_stats</key>
<param><key>id</key><value>power_power_stats_0</value></param>
<param><key>high_pwr_threshold</key><value>0.15</value></param>
<param><key>low_pwr_threshold</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>time_sink_nbr_of_points</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>time_sink_time_base * 0.1</value></param>
<param><key>tr_level</key><value>0.25</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>power_power_stats_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>power_moving_rms_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>power_moving_rms_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
